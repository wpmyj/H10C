# Keil uVision project H10C.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: H10C +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\startup;..\startup;..\user;..\user\include;..\user\userdriver;..\user\common
  group startup
    ../startup/: STARTUP_N76E003beta.A51
  group user
    ../user/: main.C
  group userdriver
    ../user/userdriver/: led.c adc.c eeprom.c timer.c uart.c
  group common
    ../user/common/: Common.c Delay.c
